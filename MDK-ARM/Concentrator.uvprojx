# Keil uVision project Concentrator.uvprojx, settings and files
target Concentrator (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Concentrator +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe  --bin -o   ..\OUTPUT\Obj\Concentrator.bin ..\OUTPUT\Obj\Concentrator.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40XX,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c include: ..\CORE;..\USER;..\DEVICEDRIVER\dp83848;..\ETHERNET;..\FREERTOS\include;..\FREERTOS\portable\RVDS\ARM_CM4F;..\FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\LWIP\lwip-1.4.1\src\include;..\LWIP\lwip-1.4.1\src\include\lwip;..\LWIP\lwip-1.4.1\src\include\ipv4;..\LWIP\lwip-1.4.1\src\include\netif;..\LWIP\lwip-1.4.1\port\STM32F4x7;..\LWIP\lwip-1.4.1\port\STM32F4x7\FreeRTOS;..\PERIPHERAL\usart;..\DEVICEDRIVER\battery;..\DEVICEDRIVER\cat25x;..\DEVICEDRIVER\dp83848;..\DEVICEDRIVER\e_meter;..\DEVICEDRIVER\ec20;..\DEVICEDRIVER\ht7038;..\DEVICEDRIVER\ht7038;..\DEVICEDRIVER\kc;..\DEVICEDRIVER\kr;..\DEVICEDRIVER\led;..\DEVICEDRIVER\rx8010s;..\DEVICEDRIVER\w25qxx;..\FATFS;..\FATFS\src;..\FATFS\exfuns;..\MEMORY;..\MIDDLEWARE;..\PROTOCOL;..\PERIPHERAL\iic;..\PERIPHERAL\spi;..\PERIPHERAL\stmflash;..\PERIPHERAL\usart;..\PERIPHERAL\watch_dog;..\EXTERNALDEVICE\concentrator;..\EXTERNALDEVICE\electricity_meter;..\EXTERNALDEVICE\input_collector;..\EXTERNALDEVICE\relay;..\USB\USB_APP;..\USB\STM32_USB_OTG_Driver\inc;..\USB\STM32_USB_HOST_Library\Core\inc;..\USB\STM32_USB_HOST_Library\Class\MSC\inc;..\EXTERNALDEVICE\lamp;..\DEVICEDRIVER\plc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Objects\Project.sct
  group USER
    ../USER/: main.c common.c stm32f4xx_it.c rtos_task.c task_4g.c task_concentrator.c task_electricity_meter.c task_handle_server_frame.c task_input_collector.c task_led.c task_relay.c task_lamp.c task_rs485.c task_plc.c task_store.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4x7_eth.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group PERIPHERAL
    ../PERIPHERAL/usart/: usart.c usart6.c
    ../PERIPHERAL/watch_dog/: watch_dog.c
    ../PERIPHERAL/spi/: spi.c
    ../PERIPHERAL/iic/: iic.c
    ../PERIPHERAL/stmflash/: stmflash.c
  group DEVICE_DRIVER
    ../DEVICEDRIVER/led/: led.c
    ../DEVICEDRIVER/dp83848/: dp83848.c
    ../DEVICEDRIVER/kc/: kc.c
    ../DEVICEDRIVER/kr/: kr.c
    ../DEVICEDRIVER/rx8010s/: rx8010s.c
    ../DEVICEDRIVER/cat25x/: cat25x.c
    ../DEVICEDRIVER/w25qxx/: w25qxx.c
    ../DEVICEDRIVER/ht7038/: ht7038.c
    ../DEVICEDRIVER/ec20/: ec20.c
    ../DEVICEDRIVER/battery/: battery.c
    ../DEVICEDRIVER/e_meter/: e_meter.c
    ../DEVICEDRIVER/plc/: plc.c
  group PROTOCOL
    ../PROTOCOL/: server_protocol.c
  group FREERTOS
    ../FREERTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FREERTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FREERTOS/portable/MemMang/: heap_4.c
  group ETHERNET
    ../ETHERNET/: fs.c httpd.c httpd_cgi_ssi.c lwip_comm.c netconf.c task_lwip_init.c task_tcp_client.c
  group LWIP
    ../LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c lwip_timers.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c udp.c
    ../LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../LWIP/lwip-1.4.1/port/STM32F4x7/FreeRTOS/: ethernetif.c sys_arch.c
    ../LWIP/lwip-1.4.1/src/netif/: etharp.c
  group FATS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/exfuns/: exfuns.c fattester.c
  group MEMORY
    ../MEMORY/: fifo.c memb.c ringbuf.c
  group MIDDLE_WARE
    ../MIDDLEWARE/: at_cmd.c history_record.c sun_rise_set.c
  group EXTERNAL_DEVICE
    ../EXTERNALDEVICE/concentrator/: concentrator_comm.c concentrator_conf.c concentrator_event.c
    ../EXTERNALDEVICE/relay/: relay_comm.c relay_conf.c relay_event.c
    ../EXTERNALDEVICE/input_collector/: input_collector_comm.c input_collector_conf.c input_collector_event.c
    ../EXTERNALDEVICE/electricity_meter/: electricity_meter_comm.c electricity_meter_conf.c electricity_meter_event.c
    ../EXTERNALDEVICE/lamp/: lamp_comm.c lamp_conf.c lamp_event.c
